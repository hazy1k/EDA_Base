# Keil uVision project project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\AC5)
  device: CW32L010F8 WHXY
  pack: WHXY.CW32L010_DFP.1.0.0
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: OneElfS=1 uC99=1 v6LangP=3 wLevel=2
  c include: ..\USER\inc;..\..\Libraries\src;..\..\Libraries\inc;..\..\IDEsupport\MDK;..\..\Libraries\inc;..\GUI
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group Startup
    ../../Libraries/src/: system_cw32l010.c
    ../../IDEsupport/MDK/: startup_cw32l010.s
  group User
    ../USER/src/: main.c interrupts_cw32l010.c seg.c ADC.C flash.c
  group Driver
    ../../Libraries/src/: cw32l010_sysctrl.c cw32l010_gpio.c cw32l010_btim.c cw32l010_adc.c cw32l010_flash.c cw32l010_systick.c
  group Doc
    ../: readme.txt
  group GUI
    ../GUI/: ntc.c
software components: CMSIS:CORE 5.4.0
